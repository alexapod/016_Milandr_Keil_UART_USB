# Keil uVision project 016_MilandrUART_USB.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 016_MilandrUART_USB +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group usb
    ./: gpio.c gpio.h main.c max31865.c max31865.h README.md system.c system.h uart.c uart.h usb.h usb.c
software components: CMSIS:CORE 6.2.0, Device:Startup 2.2.0i, Drivers:PORT 2.2.0i, Drivers:RST_CLK 2.2.0i, Drivers:SSP 2.2.0i, Drivers:UART 2.2.0i, Drivers:USB Library 2.1.0i, Drivers:USB 2.1.0i
